v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} -400 0 0 0 {name=p0 lab=a}
C {devices/iopin.sym} -400 60 0 0 {name=p1 lab=b}
C {devices/iopin.sym} -400 120 0 0 {name=p2 lab=c}
C {devices/iopin.sym} -400 180 0 0 {name=p3 lab=y}
C {devices/iopin.sym} -400 240 0 0 {name=p4 lab=vdd}
C {devices/iopin.sym} -400 300 0 0 {name=p5 lab=vss}
C {cplz_ls01/NAND3LV.sym} 200 200 0 0 {name=X1}
C {devices/lab_pin.sym} 120 200 0 0 {name=l1 sig_type=std_logic lab=a}
C {devices/lab_pin.sym} 120 220 0 0 {name=l2 sig_type=std_logic lab=b}
C {devices/lab_pin.sym} 120 240 0 0 {name=l3 sig_type=std_logic lab=c}
C {devices/lab_pin.sym} 120 260 0 0 {name=l4 sig_type=std_logic lab=yn}
C {devices/lab_pin.sym} 120 280 0 0 {name=l5 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 120 300 0 0 {name=l6 sig_type=std_logic lab=vss}
C {cplz_ls01/INVLV.sym} 540 200 0 0 {name=X2}
C {devices/lab_pin.sym} 460 200 0 0 {name=l7 sig_type=std_logic lab=yn}
C {devices/lab_pin.sym} 460 220 0 0 {name=l8 sig_type=std_logic lab=y}
C {devices/lab_pin.sym} 460 240 0 0 {name=l9 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 460 260 0 0 {name=l10 sig_type=std_logic lab=vss}
